# IAR project Backup of project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: V8530; V85XX; USE_TARGET_DRIVER; _TARGET_EWARM_USED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\fal-latest\porting; ..\..\components\libc\compilers\common; ..\..\components\drivers\usb\usbhost\core; ..\..\include; ..\..\components\drivers\usb\usbhost; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\drivers\usb\usbdevice; packages\EasyFlash-master\inc; packages\CmBacktrace-latest; .; libraries; ..\..\components\utilities\ulog; ..\..\components\drivers\spi\sfud\inc; ..\..\libcpu\arm\cortex-m0; libraries\CMSIS\include; ..\..\components\drivers\spi; applications; ..\..\components\drivers\usb\usbhost\class; ..\..\components\finsh; ..\..\components\utilities\ymodem; libraries\Lib_Driver\inc; ..\..\components\drivers\usb\usbhost\include; packages\fal-latest\inc; drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c ymodem_upgrade.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c drv_i2c.c drv_spi.c drv_eeprom.c drv_flash.c drv_wdt.c
    libraries/Config/IAR/: startup_target_noload.s
  group EasyFlash
    packages/EasyFlash-master/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    packages/EasyFlash-master/ports/: ef_fal_port.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/porting/: fal_data_flash_sfud_port.c fal_on_chip_flash_port.c fal_eeprom_port.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rt_usbd
    ../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group rt_usbh
    ../../components/drivers/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ymodem/: ymodem.c
  group v85xx_hal
    libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
    libraries/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_comp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
