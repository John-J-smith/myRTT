# IAR project Backup (11) of project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HT6x3x; HT6x3x
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\CMSIS\CM0\DeviceSupport\Inc; ..\..\components\utilities\ymodem; libraries\HT60xx_StdPeriph_Driver\Inc; ..\..\include; drivers; ..\..\components\libc\compilers\common; ..\..\components\drivers\spi; applications; ..\..\components\utilities\ulog; ..\..\components\drivers\spi\sfud\inc; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\libcpu\arm\common; libraries\CMSIS\CM0\CoreSupport; .; ..\..\components\finsh; libraries\HT60xx_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: eeprom.c main.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c drv_i2c.c drv_spi.c
    libraries/Startup/IAR/: startup_ht6x3x.s
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c
  group ht6xxx_hal
    libraries/CMSIS/CM0/DeviceSupport/Src/: system_ht6xxx.c
    libraries/HT60xx_StdPeriph_Driver/Src/: ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ymodem/: ymodem.c
