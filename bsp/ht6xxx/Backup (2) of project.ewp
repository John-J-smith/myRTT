# IAR project Backup (2) of project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; HT6x3x; HT6x3x
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\sal_socket\include\socket; packages\fal-latest\porting; ..\..\components\libc\compilers\dlib; ..\..\components\net\sal_socket\include; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\net\at\at_socket; packages\EasyFlash-master\inc; packages\at_device-latest\inc; packages\CmBacktrace-latest; ..\..\components\libc\compilers\common; .; ..\..\components\utilities\ulog; ..\..\components\drivers\spi\sfud\inc; ..\..\components\dfs\include; ..\..\libcpu\arm\cortex-m0; libraries\HT60xx_StdPeriph_Driver\Inc; libraries\HT60xx_StdPeriph_Driver; libraries\CMSIS\CM0\DeviceSupport\Inc; ..\..\components\net\sal_socket\include\socket\sys_socket; ..\..\components\net\sal_socket\impl; ..\..\components\drivers\spi; applications; ..\..\components\net\netdev\include; ..\..\components\finsh; libraries\CMSIS\CM0\CoreSupport; ..\..\components\utilities\ymodem; ..\..\components\dfs\filesystems\elmfat; ..\..\components\net\at\include; packages\fal-latest\inc; packages\at_device-latest\class\n58; drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c ymodem_upgrade.c fal_fs_part_dev.c
  group AT
    ../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/n58/: at_device_n58.c at_socket_n58.c
    packages/at_device-latest/samples/: at_sample_n58.c
  group cm_backtrace
    packages/CmBacktrace-latest/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    drivers/: board.c HD_System.c drv_gpio.c drv_uart.c drv_i2c.c drv_spi.c drv_eeprom.c drv_flash.c
    libraries/Startup/IAR/: startup_ht6x3x.s
  group EasyFlash
    packages/EasyFlash-master/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    packages/EasyFlash-master/ports/: ef_fal_port.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-latest/porting/: fal_flash_sfud_port.c fal_flash_ht6xxx_port.c fal_eeprom_port.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group ht6xxx_hal
    libraries/CMSIS/CM0/DeviceSupport/Src/: system_ht6xxx.c
    libraries/HT60xx_StdPeriph_Driver/Src/: ht6x3x_emu.c ht6xxx_aes&rand.c ht6xxx_cmu.c ht6xxx_crc.c ht6xxx_dma.c ht6xxx_ecc.c ht6xxx_exti.c ht6xxx_flash.c ht6xxx_gpio.c ht6xxx_iic.c ht6xxx_lcd.c ht6xxx_pmu.c ht6xxx_reset.c ht6xxx_rtc.c ht6xxx_spi.c ht6xxx_tbs.c ht6xxx_tdes&rand.c ht6xxx_timer.c ht6xxx_uart&7816.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c
    ../../components/net/sal_socket/impl/: af_inet_at.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ymodem/: ymodem.c
