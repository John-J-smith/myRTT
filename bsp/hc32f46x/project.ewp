# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: HT6X3X Hitrendtech HT6X3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; HC32F46x; __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\cpu_usage-latest; ..\..\components\libc\compilers\dlib; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; libraries\driver\inc; ..\..\components\dfs\filesystems\devfs; drivers; ..\..\components\libc\compilers\common; ..\..\components\utilities\ulog; .; libraries; ..\..\libcpu\arm\cortex-m4; packages\CmBacktrace-v1.4.0; ..\..\components\dfs\include; ..\..\components\drivers\spi\sfud\inc; libraries\CMSIS\include; ..\..\components\drivers\spi; applications; libraries\mcu\common; drivers\package_porting; ..\..\components\finsh; ..\..\components\utilities\ymodem; ..\..\components\dfs\filesystems\elmfat; packages\fal-latest\inc; packages\EasyFlash-v4.1.0\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: libraries\mcu\EWARM\config\HC32F46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c ymodem_upgrade.c fal_fs_part_dev.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.0/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group cpu_usage
    packages/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c drv_spi.c drv_flash.c
    drivers/package_porting/: fal_flash_sfud_port.c ef_fal_port.c
    libraries/mcu/EWARM/config/: startup_hc32f46x.s
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group h32f46xx_hal
    libraries/mcu/common/: system_hc32f46x.c
    libraries/driver/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ymodem/: ymodem.c ry_sy.c
